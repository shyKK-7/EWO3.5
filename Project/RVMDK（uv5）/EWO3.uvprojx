# Keil uVision project EWO3.uvprojx, settings and files
target EWO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED =1,__TARGET_FPU_VFP,__CC_ARM
  c misc: --diag_suppress=68,111,188,223,546,1295 --locale=english
  c include: ..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\Startup;..\..\Libraries;..\..\System;..\..\System\easyflash\plugins\types\struct2json\inc;..\..\System\easyflash\inc;..\..\System\easyflash\plugins\types
  asm include: ..\..\System\duoji;..\..\System\KEY;..\..\System\sys;..\..\System\queue_eg;..\..\System\lora;..\..\System\base64
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Startup/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40xx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group USER
    ../../User/: main.c FreeRTOSConfig.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group DOC
    ../../Doc/: readme.txt
  group Libraries
    ../../Libraries/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group System
    ../../System/delay/: delay.c
    ../../System/usart/: bsp_usart.c
    ../../System/rfid_r200/: rfid_r200.c
    ../../System/RTC/: bsp_rtc.c
    ../../System/iwdg/: iwdg.c
    ../../System/spi_flash/: spi_flash.c
    ../../System/usart_lcd/: usart_lcd.c
    ../../System/step_motor/: step_motor.c
    ../../System/stop_key/: stop_key.c
    ../../System/duoji/: duoji.c duoji.h
    ../../System/KEY/: key.c key.h
    ../../System/sys/: sys.c sys.h
    ../../System/base64/: base64.c
    ../../System/lora/: lora.c
  group FreeRTOS_CORE
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORT
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group EasyFlash
    ../../System/easyflash/plugins/types/: ef_types.c
    ../../System/easyflash/plugins/types/struct2json/src/: cJSON.c s2j.c
    ../../System/easyflash/port/: ef_port.c
    ../../System/easyflash/src/: easyflash.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
